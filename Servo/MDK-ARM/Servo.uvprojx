# Keil uVision project Servo.uvprojx, settings and files
target Servo (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32H743VITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: Servo +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32H743xx,ARM_MATH_LOOPUNROLL,ARM_MATH_CM7,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../Drivers/USER/Uart;../Drivers/USER/PWM;../Drivers/USER/Encode;../Drivers/USER/Datascope;../SYSTEM/delay;../Drivers/USER/fft;../Drivers/USER/DSP/Include;../Drivers/USER/ADC;../Drivers/USER/PGA117;..\Drivers\USER\buezzer
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Application/MDK-ARM
    ./: startup_stm32h743xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c dma.c spi.c tim.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group User/Uart
    ../Drivers/USER/Uart/: my_uart.c
  group User/PWM
    ../Drivers/USER/PWM/: PWM.c
  group User/Encode
    ../Drivers/USER/Encode/: Encode.c
  group User/Datascope
    ../Drivers/USER/Datascope/: DataScope_DP.C
  group Systerm
    ../SYSTEM/delay/: delay.c
  group User/fft
    ../Drivers/USER/fft/: fft_user.c fft.c
  group user/dsp
    ../Drivers/USER/DSP/: arm_cortexM7lfdp_math.lib
  group user/mic_adc
    ../Drivers/USER/ADC/: mic_adc.c
  group user/PGA117
    ../Drivers/USER/PGA117/: PGA117.c
  group user/buzzer
    ../Drivers/USER/buezzer/: buzzer.c
software components: CMSIS:CORE 5.6.0, Compiler:Event Recorder 1.4.0, Compiler:I/O:STDOUT 1.2.0
